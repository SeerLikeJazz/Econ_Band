# Keil uVision project STM32F411_Project.uvprojx, settings and files
target Louis_Nucleo411 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F411_Project
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: ..\Libraries\inc;..\USER;..\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../USER/: main.c bsp_led.c bsp_usart.c hardware_init.c stm_delay.c stm_I2C.c mpu9150.c stm_ADC.c stm_wkup.c bsp_motor.c
    ../USER/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group STM32F411_StdPeriph_Driver
    ../Libraries/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORE
    ../CORE/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f411xe.s
